/**
  **************************************************************************
  * @file     encoder_accel.c
  * @brief    旋转编码器变速(加速度)通用模块实现
  *
  * 变速策略：
  *   编码器累计增量 delta(4 倍频计步, EC11 每格 4 计数)按单周期幅度
  *   |delta| 分档决定"每格对应的步数", 再经实例累积器提取完整格数。
  *   慢速(|delta| 小)每格 1 步精准微调, 快速(|delta| 大)每格步进放大,
  *   实现"慢拧精准、快拧加速"的手感。步进阈值可按手感调整。
  **************************************************************************
  */

#include "encoder_accel.h"
#include <stddef.h>

/* 每格对应的计数(EC11 4 倍频: 每格 4 个状态跳变) */
#define ENC_ACCEL_CNT_PER_DETENT  4

/*********************************************************************
 * 函 数 名: encoder_accel_init
 * 入口参数: accel   变速器实例指针
 * 出口参数: 无
 * 返 回 值: void
 * 函数功能: 初始化变速器实例(清零计数累积器)
 * 修改历史:
 *   1.修改人: CodeBuddy
 *     修改日期: 2026年10月17日
 *     修改内容: 新增函数(变速调节通用模块需求)
 **********************************************************************/
void encoder_accel_init(encoder_accel_t *accel)
{
  if(accel != NULL)
  {
    accel->accum = 0;
  }
}

/*********************************************************************
 * 函 数 名: encoder_accel_feed
 * 入口参数: accel   变速器实例指针
 *           delta   编码器累计旋转增量(4 倍频计步, 正=顺时针)
 * 出口参数: 无
 * 返 回 值: int32_t 变速后的"步数"(1 步 = 慢速 1 格), 0=本次不足一格
 * 函数功能: 将旋转增量按"慢速精准、快速加速"策略换算为步数
 * 说    明: 不足一格的计数保留在实例累积器中, 下次满格再提取,
 *           保证任意转速与正反交替下不丢步; 步进阈值可按手感调整
 * 修改历史:
 *   1.修改人: CodeBuddy
 *     修改日期: 2026年10月17日
 *     修改内容: 新增函数(变速调节通用模块需求)
 **********************************************************************/
int32_t encoder_accel_feed(encoder_accel_t *accel, int32_t delta)
{
  int32_t mag;      /* 本周期速度(|delta|) */
  int32_t step;     /* 每格(4 计数)对应的步数 */
  int32_t detents;  /* 完整格数 */

  if(accel == NULL || delta == 0)
  {
    return 0;
  }

  mag = (delta < 0) ? -delta : delta;

  /* ---- Step1: 按速度分档确定每格步进(阈值可按手感调整) ---- */
  if(mag <= 4)       { step = 1; }   /* 慢速: 1格=1步 精准微调 */
  else if(mag <= 12) { step = 2; }   /* 中速: 1格=2步 */
  else if(mag <= 32) { step = 8; }   /* 快速: 1格=8步 */
  else               { step = 16; }  /* 极快: 1格=16步 */

  /* ---- Step2: 累积计数, 每满一格按 step 提取步数 ---- */
  accel->accum += delta;
  detents = accel->accum / ENC_ACCEL_CNT_PER_DETENT;
  if(detents == 0)
  {
    return 0;
  }
  accel->accum -= detents * ENC_ACCEL_CNT_PER_DETENT;  /* 保留不足一格的余数 */
  return detents * step;
}
